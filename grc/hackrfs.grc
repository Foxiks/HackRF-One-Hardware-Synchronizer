options:
  parameters:
    generate_options: qt_gui
    id: default123
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bb_1
  id: variable_qtgui_range
  parameters:
    label: BB Gain HackRF-1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '62'
    value: '39'
  states: {state: disabled}
- name: bb_2
  id: variable_qtgui_range
  parameters:
    label: BB Gain HackRF-2
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '62'
    value: '38'
  states: {state: disabled}
- name: cent_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 1948e6
  states: {}
- name: cropBW
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 15e5
  states: {}
- name: if_1
  id: variable_qtgui_range
  parameters:
    label: IF Gain HackRF-1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {state: disabled}
- name: if_2
  id: variable_qtgui_range
  parameters:
    label: IF Gain HackRF-2
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_agc_xx_0_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.010e-3'
    reference: '1'
    type: complex
  states: {}
- name: analog_agc_xx_0_0_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.010e-3'
    reference: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '- (samp_rate / 2)+cropBW'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate * 2
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: (samp_rate / 2) -cropBW
    offset: '0'
    phase: '0'
    samp_rate: samp_rate * 2
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\user\Desktop\2.wav
    type: short
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: C:\Users\user\Desktop\1.wav
    nchan: '2'
    samp_rate: '40000000'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\user\Desktop\HackRF_20220123_180441Z_421500kHz_IQ.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\user\Desktop\HackRF_20220123_180441Z_438500kHz_IQ.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: cent_freq
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-95'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [analog_agc_xx_0_0_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_1, '0', analog_agc_xx_0_0_0, '0']
- [blocks_float_to_complex_1_0, '0', analog_agc_xx_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_1, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_1, '1']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_wavfile_source_0_0, '1', blocks_float_to_complex_1_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_1, '1']

metadata:
  file_format: 1
